# ODROID-XU4
LED_FILE_odroid-xu4 = "/sys/class/leds/blue\:heartbeart/brightness"

# ODROID-C1
LED_FILE_odroid-c1 = "/sys/class/leds/blue\:heartbeat/brightness"
