IMAGE_FSTYPES_remove_odroid-xu4 = " wic wic.xz"
IMAGE_FSTYPES_remove_odroid-c1 = " wic wic.xz"
